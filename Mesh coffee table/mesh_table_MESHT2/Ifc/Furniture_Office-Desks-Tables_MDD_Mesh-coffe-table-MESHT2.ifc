Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Furniture_Office-Desks-Tables_MDD_Mesh-coffe-table-MESHT2.ifc
Time: 2019-09-17T12:48:01
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: Mesh coffe table MESHT2
ePset_BIMobjectScript - Base bottom colour: Runner R-66064; Base top colour: Runner R-66064; Top colour: Aluminium Satinato; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Mesh coffe table MESHT2; SKU (BO_prodsku): mesh_table_MESHT2; ManufacturName (BO_Manufac): MDD; BrandUrl (BO_brandurl): http://www.mdd.eu; ProductFamily (BO_prodfam): Soft Seating; ProductGroup (BO_prodgroup): Mesh; ManufacturCountry (BO_mancont): Poland; DesignCountry (BO_designcont): Poland; EditionNumber (BO_edinum): 1; Width (BO_width): 450; Height (BO_height): 579; Depth (BO_depth): 450; Weight (BO_weight): 7; QR (BO_boqrurl): http://bimobject.com/mdd/product/mesh_table_MESHT2; ProductDataUrl (BO_prodaturl): bimobject.com/mdd/product/mesh_table_MESHT2; ProductUrl (BO_producturl): http://mdd.eu/en/soft-seating/mesh/; TechnicalDescription (BO_techcert): http://mdd.eu/wp-content/uploads/2017/07/mesh-1-1.pdf; MaterialMain (BO_mainmat): Fabric; MaterialSecondary (BO_secmat): Melamine; BimObjectMainCategory (BO_bomaincat): Furniture; BimObjectMainCategoryCode (BO_bomaincat_code): furniture; BimObjectCategory (BO_bocat): Office Desks & Tables; BimObjectCategoryCode (BO_bocat_code): furniture-office-desks-tables; IfcClassification (BO_ifcclas): Furniture; Uniclass2015Code (BO_uniclass2015_code): Pr_40_50_21_14; Uniclass2015Description (BO_uniclass2015_desc): Coffee tables; OmniClassCode (BO_omniclass_code): 23-21 23 15 17; OmniClassDescription (BO_omniclass_name): Residential Coffee Tables; MasterFormat2014Code (BO_masterformat2014_code): 12 58 23; MasterFormat2014Description (BO_masterformat2014_name): Coffee Tables; RegionEurope (BO_europe): AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, SM, UA, VA; RegionNorthAmerica (BO_northamerica): AG, AI, AW, BB, BL, BM, BQ, BS, BZ, CA, CR, CU, CW, DM, DO, GD, GL, GP, GT, HN, HT, JM, KN, KY, LC, MF, MQ, MS, MX, NI, PA, PM, PR, SV, SX, TC, TT, US, VC, VG, VI; RegionSouthAmerica (BO_southamerica): AR, BO, BR, CL, CO, EC, FK, GF, GY, PE, PY, SR, UY, VE; RegionMiddleEast (BO_middleeast): AE, AF, BH, EG, IL, IQ, IR, JO, KW, LB, OM, PS, QA, SA, SY, TR, YE; RegionAsia (BO_asia): AM, AZ, BD, BN, BT, CC, CN, CX, GE, HK, ID, IN, IO, JP, KG, KH, KR, KZ, LA, LK, MM, MN, MO, MV, MY, NP, PH, PK, SG, TH, TJ, TM, TW, UZ, VN; RegionOceania (BO_oceania): AS, AU, CK, FJ, FM, GU, KI, MH, MP, NC, NF, NR, NU, NZ, PF, PG, PN, PW, SB, TK, TL, TO, TV, UM, WF, WS, VU; RegionAfrica (BO_africa): AO, BF, BI, BJ, BW, CD, CF, CG, CI, CM, CV, DJ, DZ, EH, ER, ET, GA, GH, GM, GN, GQ, GW, KE, KM, LR, LS, LY, MA, MG, ML, MR, MU, MW, MZ, NA, NE, NG, RE, RW, SC, SD, SH, SL, SN, SO, SS, ST, SZ, TD, TG, TN, TZ, UG, YT, ZA, ZM, ZW
